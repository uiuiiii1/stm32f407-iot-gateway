# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c misc: --locale=english
  c include: .\Start;.\Library\inc;.\User;.\Hardware;.\Bootloader
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx.h system_stm32f4xx.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group User
    ./User/: main.c stm32f4xx_conf.h
  group Library
    ./Library/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c
  group Hardware
    ./Hardware/: usart.c usart.h tick.c tick.h spi2.c spi2.h w25q64.c w25q64.h AT24C64.c AT24C64.h
  group Bootloader
    ./Bootloader/: App_bootloader.c App_bootloader.h Int_bootloader.c Int_bootloader.h
