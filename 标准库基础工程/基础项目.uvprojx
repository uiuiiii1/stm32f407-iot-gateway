# Keil uVision project 基础项目.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: 基础项目 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,_WIZCHIP_=5500
  c misc: --locale=english
  c include: .\Start;.\Library\inc;.\User;.\Hardware;.\Ethernet;.\Ethernet\W5500;.\Ethernet\DNS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: startup_stm32f40_41xxx.s system_stm32f4xx.h system_stm32f4xx.c stm32f4xx.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group User
    ./User/: main.c stm32f4xx_it.h stm32f4xx_it.c stm32f4xx_conf.h
  group Library
    ./Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Hardware
    ./Hardware/: lcd_spi_154.h lcd_spi_154.c lcd_fonts.h lcd_fonts.c delay.h delay.c i2c.h i2c.c ds1307.h ds1307.c modbus.h modbus.c spi2.h spi2.c w25q64.h w25q64.c w5500_bsp.h w5500_bsp.c mqtt.h mqtt.c usart.h usart.c rtc.h rtc.c
  group Ethernet
    ./Ethernet/: socket.h socket.c wizchip_conf.h wizchip_conf.c
    ./Ethernet/W5500/: w5500.h w5500.c
    ./Ethernet/DNS/: dns.h dns.c
