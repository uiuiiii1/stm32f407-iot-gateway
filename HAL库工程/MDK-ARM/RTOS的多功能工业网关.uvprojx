# Keil uVision project RTOS的多功能工业网关.uvprojx, settings and files
target RTOS的多功能工业网关 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RTOS的多功能工业网关 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,_WIZCHIP_=5500
  c misc: --locale=english
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Hardware;../Ethernet;../Ethernet/W5500;../Ethernet/DNS;../FreeRTOS;../FreeRTOS/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c app.c gpio.c rtc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Core/Inc/: app.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Hardware
    ../Hardware/: delay.c usart_app.c lcd_spi_154.c lcd_fonts.c w5500_bsp.c modbus.c mqtt.c rtc_app.c
  group Ethernet
    ../Ethernet/: socket.c wizchip_conf.c
    ../Ethernet/W5500/: w5500.c
    ../Ethernet/DNS/: dns.c
  group FreeRTOS
    ../FreeRTOS/: tasks.c list.c queue.c event_groups.c stream_buffer.c port.c heap_4.c
software components: CMSIS:CORE 4.3.0
